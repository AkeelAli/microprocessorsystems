# Keil uVision project lab_2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab_2
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ".\STM32F10x";"..\Lab 2_final";.\inc;.\iNEMO_Lib;
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s main.c stm32f10x_conf.h HAL_LSM303DLH.h stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c LSM303DLH.h debugger.c stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_spi.c rf2500.c
    ./STM32F10x/: system_stm32f10x.c
    ./iNEMO_Lib/LPS001DL/src/: LPS001DL_I2C.c
