# Keil uVision project akeel.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: akeel
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Akeel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: atan_LUT.c debugger.c LPRYxxxAL.c LSM303DLH.c main.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c STM32F10x.s gestures.c mgest_stack.c cc2500.c spi_protocol.c stm32f10x_spi.c
  group Header Files
    ./: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_tim.h atan_LUT.h core_cm3.h HAL_LPRYxxxAL.h HAL_LSM303DLH.h LPRYxxxAL.h LSM303DLH.h gestures.h mgest_stack.h cc2500.h spi_protocol.h stm32f10x_spi.h
