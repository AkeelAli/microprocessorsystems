# Keil uVision project final.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: final
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: "..\NEW_MASTER"
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: STM32F10x.s atan_LUT.c communication.c debugger.c gesture_latch.c gestures.c LPRYxxxAL.c LSM303DLH.c main.c mgest_stack.c misc.c protocol.c rf2500.c service_functions.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c iNEMO_led.c
  group Header
    ./: atan_LUT.h C2500.h communication.h core_cm3.h gesture_latch.h gestures.h HAL_LPRYxxxAL.h HAL_LSM303DLH.h LPRYxxxAL.h LSM303DLH.h mgest_stack.h misc.h protocol.h rf2500.h service_functions.h stm32f10x.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h iNEMO_led.h
